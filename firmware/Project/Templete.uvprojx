# Keil uVision project Templete.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.44
  cpu: IROM(0x00000000,0x1FE00) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\Libraries\CMSIS\Include;..\Libraries\Device\Holtek\HT32F5xxxx\Include;..\Libraries\HT32F5xxxx_Driver\inc;..\Libraries\HT32_USBD_Library\inc;..\Utilities;..\Libraries;..\HARDWARE\LED;..\HARDWARE\Delay;..\HARDWARE\uart;..\HARDWARE\dht11;..\HARDWARE\adc;..\NET\device\inc;..\NET\onenet\inc;..\HARDWARE\USART;..\NET\MQTT;..\HARDWARE\fire;..\NET\CJSON;..\HARDWARE\time;..\Utilities\HT32_Board;..\NET\ESP8266;..\HARDWARE\uart;..\HARDWARE\oled;..\HARDWARE\AS608;..\HARDWARE\USART;..\HARDWARE;..\HARDWARE\infrared;..\HARDWARE\My_buzzer;..\HARDWARE\My_key;..\HARDWARE\SW_18015P;..\HARDWARE\My_servo;..\HARDWARE\time1;..\HARDWARE\onenet;..\HARDWARE\SGP30;..\HARDWARE
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group USER
    ../User/: main.c ht32f5xxxx_01_it.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/adc/: adc.c
    ../HARDWARE/: sys.h
    ../HARDWARE/time1/: time1.c
    ../HARDWARE/SGP30/: SGP30.c SGP30.h iic.c iic.h
    ../HARDWARE/infrared/: infrared.c infrared.h
    ../HARDWARE/My_buzzer/: My_buzzer.c My_buzzer.h
    ../HARDWARE/My_key/: My_key.h My_key.c
    ../HARDWARE/My_servo/: My_servo.c My_servo.h
    ../HARDWARE/SW_18015P/: SW_18015P.h SW_18015P.c
    ../HARDWARE/Delay/: delay.c delay.h
  group CONFIG
    ../Libraries/: ht32f5xxxx_conf.h ht32f5xxxx_01_usbdconf.h HT32F5xxxx_01_DebugSupport.ini ht32_board_config.h
    ../Listing/: ht32_op.s
  group CMSIS
    ../Libraries/: system_ht32f5xxxx_01.c
  group MDK-ARM
    ../Listing/: startup_ht32f5xxxx_01.s
  group USBD_LIBRARY
    ../Libraries/HT32_USBD_Library/src/: ht32_usbd_core.c
  group LIBRARY
    ../Libraries/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32_retarget.c ht32_serial.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c printf.c
  group UTILITES
    ../Utilities/: ht32_board.c
    ../Utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group ESP8266
    ../NET/ESP8266/: esp8266.c
  group USART
    ../HARDWARE/USART/: usart.c usart.h
  group no use
    ../HARDWARE/AS608/: bsp_led.h data_queue.c data_queue.h ht32f52352_sk.h malloc.c malloc.h time.c time.h
  group UART
    ../HARDWARE/uart/: uart.c uart.h
  group OLED
    ../HARDWARE/oled/: oled.c oled.h oledfont.h
  group onenet
    ../HARDWARE/onenet/: cJSON.c cJSON.h Common.h MqttKit.c MqttKit.h onenet.c onenet.h
